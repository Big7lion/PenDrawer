# Keil uVision project 3Dprinter_firmware.uvprojx, settings and files
target 3Dprinter_firmware (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 3Dprinter_firmware +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F10x_FWLib\inc;..\..\System\inc;..\..\Hardware\LCD;..\..\Hardware\BEEP;..\..\Hardware\SWITCH;..\..\Hardware\PWMOUTPUT;..\..\Hardware\24CXX;..\..\Hardware\FLASH;..\..\Hardware\SRAM;..\..\Hardware\TOUCH;..\..\Hardware\WATCHDOG;..\..\USMART;..\..\MALLOC;..\..\Step_motor;..\..\Thermistor;..\..\Fatfs\src;..\..\Fatfs\exfuns;..\..\Text;..\..\APP;..\..\Gui;..\..\PICTURE;..\..\Hardware\SD_SDIO;..\..\Setup;..\..\Dlion
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../../System/src/: delay.c system_stm32f10x.c sys.c usart.c adc.c iic.c rtc.c spi.c
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_sdio.c
  group Hardware
    ../../Hardware/LCD/: lcd.c
    ../../Hardware/BEEP/: beep.c
    ../../Hardware/SWITCH/: switch.c
    ../../Hardware/24CXX/: 24cxx.c
    ../../Hardware/FLASH/: flash.c
    ../../Hardware/SRAM/: sram.c
    ../../Hardware/TOUCH/: touch.c
    ../../Hardware/WATCHDOG/: watchdog.c
    ../../Hardware/SD_SDIO/: sdio_sdcard.c
  group Malloc
    ../../Malloc/: malloc.c
  group Fatfs
    ../../Fatfs/exfuns/: exfuns.c fattester.c mycc936.c
    ../../Fatfs/src/: diskio.c ff.c
  group Text
    ../../Text/: fontupd.c text.c
  group Picture
    ../../PICTURE/: bmp.c piclib.c
    ../../Picture/: gif.c tjpgd.c
  group Gui
    ../../Gui/: lcdmenu.c gui.c button.c filelistbox.c scrollbar.c
  group User
    ../../User/: main.c
  group Startup
    ../../Startup/: startup_stm32f10x_hd.s
  group Step_motor
    ../../Step_motor/: stepper.c
  group Thermistor
    ../../Thermistor/: temperature.c
  group App
    ../../APP/: gcodeplayer.c
  group Dlion
    ../../Dlion/: Dlion.c ConfigurationStore.c motion_control.c planner.c
software components: CMSIS:CORE 4.3.0
