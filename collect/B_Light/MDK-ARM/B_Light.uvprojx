# Keil uVision project B_Light.uvprojx, settings and files
target B_Light (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: B_Light
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c oled.c nrf24l01.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c
software components: CMSIS:CORE 4.1.0
