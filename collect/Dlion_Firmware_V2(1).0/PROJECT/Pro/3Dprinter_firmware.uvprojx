# Keil uVision project 3Dprinter_firmware.uvprojx, settings and files
target 3Dprinter_firmware (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 3Dprinter_firmware +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F10x_FWLib\inc;..\..\Hardware\BEEP;..\..\Hardware\24CXX;..\..\Hardware\FLASH;..\..\Hardware\SRAM;..\..\Hardware\WATCHDOG;..\..\Step_motor;..\..\THEMISTOR;..\..\Dlion;..\..\SYSTEM\adc;..\..\SYSTEM\delay;..\..\SYSTEM\iic;..\..\SYSTEM\spi;..\..\SYSTEM\sys;..\..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c
  group Dlion
    ../../Dlion/: ConfigurationStore.c Dlion.c motion_control.c planner.c
  group Step_motor
    ../../Step_motor/: stepper.c
  group Thermistor
    ../../THEMISTOR/: temperature.c
  group Hardware
    ../../Hardware/BEEP/: beep.c
    ../../Hardware/24CXX/: 24cxx.c
    ../../Hardware/FLASH/: flash.c
    ../../Hardware/WATCHDOG/: watchdog.c
  group System
    ../../SYSTEM/adc/: adc.c
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/iic/: iic.c
    ../../SYSTEM/spi/: spi.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_it.c system_stm32f10x.c
  group Startup
    ../../Startup/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.3.0
